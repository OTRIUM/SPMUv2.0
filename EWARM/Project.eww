<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MFC-PCU-MCU.ewp</path>
  </project>
  <batchBuild />
</workspace>
